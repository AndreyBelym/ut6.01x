# Keil uVision project Lab8.uvproj, settings and files
target Lab8 (ARM-ADS)
  device: LM4F120H5QFR Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab8
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: startup.s SwitchLEDInterface.c
  group Object code
    ./: texas.o
